# Keil uVision project Sumadora.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT48801 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Sumadora +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Sumadora.a51
