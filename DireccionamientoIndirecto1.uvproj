# Keil uVision project DireccionamientoIndirecto1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32E Microchip
  cpu: IRAM(0-0xFF)  CLOCK(30000000)
  output: DireccionamientoIndirecto1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DireccionamientoIndirecto1.a51
