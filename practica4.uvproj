# Keil uVision project practica4.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32E Microchip
  cpu: IRAM(0-0xFF)  CLOCK(30000000)
  output: practica4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: practica4.a51
